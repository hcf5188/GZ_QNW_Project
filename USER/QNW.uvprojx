# Keil uVision project QNW.uvprojx, settings and files
target GZ_Code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GZ_code +hex
  AfterMake: $KARM\BIN\ELFDWT.EXE       "#L"     BASEADDRESS(0x8004800)
  AfterMake: $KARM\ARMCC\BIN\fromelf.exe      --bin     --bincombined      --output      "#L.bin"     "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USE_STM3210C_EVAL,USE_USB_OTG_FS
  c include: ..\USER;..\SYSTEM;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\CORE;..\LIB\inc;..\DEAL;..\HAEDWARE;..\USB\inc
  memory RVCT4: ROM 0x8004800 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../HAEDWARE/: bsp.c RS232_485Task.c
    ./: main.c
  group DEAL
    ../DEAL/: memBlock.c memQ.c memStore.c
  group RS232_485
    ../HAEDWARE/: RS485uartInit.c
  group CORE
    ../SYSTEM/: sys.c
    ../CORE/: core_cm3.c
    ./: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_cl.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOS-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOS-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group ReadMe
    ./: readme.txt
